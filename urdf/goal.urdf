Commit message: 1104

File: urdf/goal.urdf (robot description, URDF)
Before this commit: robot robot, 2 links, 1 joints
Links:
- link base: geometry collision cylinder length=0.1 radius=0.25
